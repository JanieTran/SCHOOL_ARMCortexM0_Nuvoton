# Keil uVision project Nu-LB-NUC140_LCD_SimpleGame.uvproj, settings and files
target LCD_SimpleGame (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: LCD_SimpleGame
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\..\..\Library\NUC1xx-LB_002\Include;..\..\..\..\Library\NuMakerLib\Include;..\;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c uart.c spi.c gpio.c
    ../../../../Library/NuMakerLib/Source/: Draw2D.c
  group User
    ../: main.c
    ../../../../Library/NuMakerLib/Source/: SYS_init.c
    ../../../../Library/NUC1xx-LB_002/Source/: LCD.c
